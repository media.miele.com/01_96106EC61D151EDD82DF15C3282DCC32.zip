Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-07-19T15:29:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 19 15:29:36 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\253cb012-ff46-4930-8322-2e7e4f84b71a\6eb1d8f6-c4a9-4bcb-9183-7c94f7351d4d\ifc * Database version: 5507 * Database creation date: Tue Jul 19 15:29:35 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 19 15:29:36 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 19 15:29:36 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12108900_OER_KD4172E_EL:38417251_OER_12108900_KD4172E_EL, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 38417251_OER_12108900_KD4172E_EL
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 38417251_OER_12108900_KD4172E_EL
Type - Pset_ProvisionForVoid - Width: 600 mm; Height: 1860 mm; Depth: 650 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - sets with these values: 2
